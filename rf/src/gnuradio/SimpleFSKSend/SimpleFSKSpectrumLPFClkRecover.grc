<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate_hz</value></param>
<param><key>value</key><value>9600</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>434000000</value></param>
<param><key>label</key><value>Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>400000000</value></param>
<param><key>step</key><value>1000000</value></param>
<param><key>stop</key><value>470000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_deviation_hz</value></param>
<param><key>value</key><value>19200</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lpf_co</value></param>
<param><key>comment</key><value>30k seems good</value></param>
<param><key>value</key><value>20000</value></param>
<param><key>gui_hint</key><value>tabs@1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>10000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lpf_tw</value></param>
<param><key>comment</key><value>30k seems good</value></param>
<param><key>value</key><value>20000</value></param>
<param><key>gui_hint</key><value>tabs@1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>10000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>sample_rate/baud_rate_hz</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>1000000</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1000000</value></param>
<param><key>step</key><value>500000</value></param>
<param><key>stop</key><value>10000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>squelch</value></param>
<param><key>value</key><value>-40</value></param>
<param><key>gui_hint</key><value>tabs@1</value></param>
<param><key>label</key><value>Squech</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>10</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_0</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>threshold</key><value>squelch</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/file_sink</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.1</value></param>
<param><key>gain_omega</key><value>0.01</value></param>
<param><key>mu</key><value>0</value></param>
<param><key>omega_relative_limit</key><value>0.01</value></param>
<param><key>omega</key><value>samp_per_sym</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_bb</key>
<param><key>id</key><value>digital_correlate_access_code_tag_bb_0</value></param>
<param><key>access_code</key><value>10101010101010101010101010101010</value></param>
<param><key>tagname</key><value>preamble</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>lpf_co</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>width</key><value>lpf_tw</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>sample_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>tabs@0</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"cyan"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>sample_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>tabs@1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"cyan"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tabs@2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>sample_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>sample_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>tabs@0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>label0</key><value>Spectrum</value></param>
<param><key>label1</key><value>LPF</value></param>
<param><key>label2</key><value>Processing</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wex_tag_printer</key>
<param><key>id</key><value>wex_tag_printer_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>len</key><value>20</value></param>
<param><key>tag_name</key><value>preamble</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>wex_tag_printer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_simple_squelch_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
