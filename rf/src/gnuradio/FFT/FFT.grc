<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>88900000</value></param>
<param><key>label</key><value>Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>88000000</value></param>
<param><key>step</key><value>1000000</value></param>
<param><key>stop</key><value>470000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>10000000</value></param>
<param><key>label</key><value>Samle Rate</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1000000</value></param>
<param><key>step</key><value>500000</value></param>
<param><key>stop</key><value>10000000</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>1</value></param>
<param><key>quad_rate</key><value>500000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>ok_to_block</key><value>False</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>sample_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"cyan"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>sample_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
